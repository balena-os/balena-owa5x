LED_FILE:owa5x-nand = "/sys/class/leds/ledsw2:red/brightness"
