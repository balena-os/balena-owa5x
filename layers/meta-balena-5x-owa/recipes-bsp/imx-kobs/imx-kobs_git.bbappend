# This version fixes error "We can not read ROM version"

SRCREV = "269fdffcf97238684de9f28977a73677282e061f"
