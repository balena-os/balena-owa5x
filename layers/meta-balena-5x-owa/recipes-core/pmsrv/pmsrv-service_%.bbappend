FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
            file://pmsrv.service \
"    