IMAGE_ROOTFS_MAXSIZE = "50000"
