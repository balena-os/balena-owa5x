do_install:append () {
    echo "Welcome to OWA5X PLATFORM BalenaOS based on Owasys FW v2.2.0-rc4 April 2026" > ${D}${sysconfdir}/issue.owa
}